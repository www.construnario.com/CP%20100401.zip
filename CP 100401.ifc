Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\IFC\CP 100401.ifc
Time: 2017-01-23T17:45:06
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: CALZO ANTIDESLIZANTE, CP100401
In: Planta Baja
Description: CALZO NIVELACIÓN; Material: Color_01
PROPIEDADES GENERALES - DENSIDAD: 905 Kg/m3 (ISO 1183); TEMPERATURA MÁXIMA ALMACENAMIENTO: 60º C; RESISTENCIA QUÍMICA: ÁCIDOS, ÁLCALIS Y DISOLVENTES; RADIACIÓN ULTRAVIOLETA: BUENO; COLOR STANDARD: NEGRO; COMPOSICIÓN: COMPOSITE POLIPROPILENO; PESO POR UNIDAD: 5 g
PROPIEDADES TERMICAS - TEMPERATURA H.D.T.: 74º C (ISO 75/B)
Pset_ManufacturerTypeInformation - ArticleNumber: CALZO NIVELACIÓN ANTIDESLIZANTE; ModelReference: CP 100401; ModelLabel: CP100401; Manufacturer: JOMBAR; ProductionYear: 2017
PROPIEDADES MECÁNICAS - MODULO ELASTICIDAD YOUNG: 1280 MPa (ISO 178); RESISTENCIA AL IMPACTO: NO ROMPE; RESISTENCIA A LA COMPRESIÓN: >127 MPa (ISO 604) NO ROMPE; DEFORMACIÓN A FUERZA MÁXIMA DE ELONGACIÓN: 1,9 % (ISO 604); CARGA MÁXIMA POR cm2: >1300 Kg
